# Keil uVision project Master_ver4.uvprojx, settings and files
target Master_ver4 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Master_ver4
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Drivers/STM32F4xx_HAL_Driver/Inc;C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FatFs/src/drivers;C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FatFs/src;C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FreeRTOS/Source/include;C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_sd.c stm32f4xx_hal_gpio.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c tasks.c timers.c queue.c list.c
    C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: fatfs.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_hal_msp.c stm32f4xx_it.c bsp_driver_sd.c freertos.c main.c
    ../Inc/: lcd_txt.c lcdDisplay.c
  group Middlewares/FatFs
    C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FatFs/src/: ff.c diskio.c ff_gen_drv.c
    C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    C:/Users/Giang/STM32Cube/Repository/STM32Cube_FW_F4_V1.16.0/Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
software components: CMSIS:CORE 4.1.0
